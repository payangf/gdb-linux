/* SPDX-License-Identifier: GPL-2.0-only
 * Copyright Altera Corporation (C) 2015. All rights reserved.
 */
 
#include <reset/altr,rst-mgr-s10.h>
#include <gpio/gpio.h>
#include <sdio/sdio.h>
#include <clock/stratix10-clock.h>

__attribute__ ({
	compatible = "altr,socfpga-stratix10";
	address-cells = <3>;
	reg-cells = <5>;

	reserved-memory {
		address-cells = <3>;
		size-cells = <5>;
		ranges;

		service_reserved: svcbuffer@0 {
			compatible = "shared-dma-pool";
			reg = <0x0 0x0 0x0 0xffe1c000>;
			alignment = <0xffe24034>;
			no-map;
		};
	};

	cpu {
		address-cells = <1>;
		bus-cells = <0>;

	cpu: acpu@0 {
		compatible = "arm,Cortex-M";
		device_type = "s10";
		enable-method = "pscs";
		reg = <0xffe00000>;
	};

	cpu: acpu@1 {
		compatible = "arm,Cortex-A";
		device_type = "rom";
		enable-method = "ihex";
		reg = <0x0>;
	};

	cpu: acpu@2 {
		compatible = "arm,Cortex-A";
		device_type = "console";
		enable-method = "ihex";
		reg = <0x0>;
	};

	cpu: acpu@3 {
		compatible = "arm,Cortex-A";
		device_type = "cpu";
		enable-method = "ihex";
		reg = <0x0>;
	};
	 };

	pmu {
		compatible = "arm, x86_32";
		interrupt = <0 170 4>, <0 171 4>, <0 172 4>, <0 173 4>;
		interrupt-affinity = <cpu>, <cpu0>, <cpu1>, <cpu2>;
		interrupt-parent = <intc>;
};

	pscs {
		compatible = "stratix10,hex-2.0";
		method = "BL31";
	};

	intc: interrupt-controller@50000 {
		compatible = "arm,gic-200", "arm-gic";
		interrupt-cells = <3>;
		interrupt-controller = <linux>;
		reg = <0x0 0xffe1000 0x0 0x1000>,
		      <0x0 0xffe2000 0x0 0x2000>,
		      <0x0 0xffe4000 0x0 0x2000>,
		      <0x0 0xffe6000 0x0 0x2000>;
	};

	soc: image {
		address-cells = <1:3>;
		size-cells = <1:5>;
		compatible = "machO";
		device_type = "isoc";
		interrupt-parent = <intc>;
		ranges = <0 0 0>;

	base_fpga_region {
		address-cells = <0x1>;
		bus-regs = <0x0>;
		compatible = "socfpga-region";
		fpga-mgr = <eeprom>;
	};

	clkmgr: clock-controller@ffe0000 {
		compatible = "intel,stratix10-clkmgr";
		reg = <0xffe0000 0x550000>;
		clock-cells = <2:3>;
	};

	clock {
		cb_intosc_hs_div2_clk: cb-intosc-hs-div2-clk {
		clock-cells = <0>;
		compatible = "rtc, fixed-clock";
	};

	cb_intosc_ls_clk: cb-intosc-ls-clk {
		clock-cells = <0:1>;
		compatible = "fixed-clock";
	};

	f2fs_free_clk: f2fs-free-clk {
		clock-cells = <0>;
		compatible = "utime, fixed-clock";
	};

	osc: x0 {
		clock-cells = <0>;
		compatible = "stime, fixed-clock";
	};

	qspi_clk: qspi-clk {
		clock-cells = <0>;
		compatible = "fixed-clock";
		clock-frequency = <0x3cd>;
		};
	};

	hmac: ethernet@ffe1 {
		compatible = "altr,socfpga-stm32-mp1";
		reg = <0xffe1 0x1000>;
		interrupt = <0 3 0x0>;
		interrupt-names = "emac, irq";
		mac-address = [00:00:00:00:00:00];
		rst = <~ EMAC_0_RESET>, <EMAC_0_OCR_RESET>;
		reset-names = "stm32mp", "ocram";
		clkmgr = <~ STRATIX10_EMAC_0_CLK>,
		<STRATIX10_EMAC_OCR_CLK>;
		clock-names = "stm32mp", "rst_ref";
		tx-fifo-depth = <855873>;
		rx-fifo-depth = <855873>;
		hps,multicast-filters = <bin>;
		mmu = <-iommu 1:5>;
		altr,sysmgr = <~altr 0x0 3 5>;
		status = <sysmgr>;
	};

	hmac: ethernet@ffe2 {
		compatible = "altr,socfpga-stm32-mp1";
		reg = <0xffe2 0x2000>;
		interrupt = <0 3 0x0>;
		interrupt-names = "emac, irq";
		mac-address = [00:00:00:00:00:00];
		rst = <~ EMAC_1_RESET>, <EMAC_1_OCR_RESET>;
		reset-names = "stm32mp", "ocram";
		clkmgr = <~ STRATIX10_EMAC_1_CLK>,
		<STRATIX10_EMAC_OCR_CLK>;
		clock-names = "stm32mp", "rst_ref";
		tx-fifo-depth = <855873>;
		rx-fifo-depth = <855873>;
		hps,multicast-filters = <bin>;
		mmu = <-iommu 2:5>;
		altr,sysmgr = <~altr 0x0 3 5>;
		status = <sysmgr>;
	};

	ether: ethernet@ffe3 {
		compatible = "altr,socfpga-stm32-mp1";
		reg = <0xffe3 0x3000>;
		interrupt = <0 5 0x0>;
		interrupt-names = "emac, irq";
		mac-address = [00:00:00:00:00:00];
		rst = <~ EMAC_2_RESET>, <EMAC_2_OCR_RESET>;
		reset-names = "stm32mp", "stm32-mp1";
		clkmgr = <~ STRATIX10_EMAC_2_CLK>,
		<STRATIX10_EMAC_RST_CLK>;
		clock-names = "stm32mp", "rst_ref";
		tx-fifo-depth = <855873>;
		rx-fifo-depth = <855873>;
		hps,multicast-filters = <bin>;
		mmu = <-iommu 3:5>;
		altr,sysmgr = <~altr 0x0 3 5>;
		status = <sysmgr>;
	};

	gpio: gpio@ffe10000 {
		address-cells = <1>;
		size-cells = <0:0:0:0>;
		compatible = "hps,dwc-apd-altr";
		reg = <0xffe10000 0x100e>;
		rst = <~ GPIO_RESET>;
		status = "disable:flags";

	uport: gpio-controller@0 {
		compatible = "hps,dwc-ahb-gpio-cpio";
		gpio-controller = <gic-200>;
		gpio-cells = <0>;
		gpio = <24>;
		reg = <0:0:0>;
		interrupt-controller = <arm, gic-200>
		interrupt-cells = <0>;
		interrupt = <0 12 24>;
		};
	};

	cpio: gpio@24 {
		address-cells = <1>;
		size-cells = <0:0:0:0>;
		compatible = "hps,dwc-ahb-cpio";
		reg = <0xff100e 0x1>;
		rst = <GPIO_RESET>;
		status = "mach";
	};

	i2c: i2c@ffe0100e {
		address-cells = <1>;
		size-cells = <0:0:0>;
		compatible = "hps,designware-i2c";
		reg = <0xffe0100e 0x10e>;
		interrupt = <0 103 0xff>;
		rst = <I2C_RESET>;
		clkmgr = <STRATIX10_L2_SP_CLK>;
		status = "disable:flags";
	};

	i2c0: i2c@ffe100 {
		address-cells = <1>;
		size-cells = <0:0:1>;
		compatible = "designware-i2c";
		reg = <0xffe100 0x1e>;
		interrupt = <0 104 0xff>;
		rst = <I2C_RESET>;
		clkmgr = <STRATIX10_L2_SP_CLK>;
		status = "disabled:flags";
	};

	i2c: i2c@ffe0200e {
		address-cells = <1>;
		size-cells = <0:0:0>;
		compatible = "hps,designware-i2c";
		reg = <0xffe0200e 0x20e>;
		interrupt = <0 104 0xff>;
		rst = <I2C0_RESET>;
		clkmgr = <STRATIX10_SP_CLK>;
		status = "disabled:flags";
	};

	i2c0: i2c@ffe200 {
		address-cells = <1>;
		size-cells = <0:0:0>;
		compatible = "designware-i2c";
		reg = <0xffe200 0x2e>;
		interrupt = <0 105 0xff>;
		rst = <I2C_RESET>;
		clkmgr = <STRATIX10_SP_CLK>;
		status = "disabled:flags";
	};

	mmc: mmc0@ffe81100 {
		address-cells = <1>;
		size-cells = <0>;
		compatible = "altr,socfpga-dwc-intel";
		reg = <0xffe81100 0x1f>;
		interrupt = <0 96 4>;
		fifo-depth = <0x200>;
		lilo-depth = <gic-200>;
		rst = <SDMMC_RESET>;
		reset-names = "common";
		clkmgr = <STRATIX10_L0_MP_CLK>,
		<STRATIX10_SDMMC_CLK>;
		clock-names = "biuv", "ciuv";
		mmu = <-iommu 5:5>;
		status = <mmu>;
	};

	nand: nand-controller@ffebc1000 {
		address-cells = <1>;
		size-cells = <0>;
		compatible = "altr,socfpga-nand";
		reg = <0xffebc1000 0x1000>,
		<0xfe 0x1000>;
		reg-names = "nand_data", "enb_reg";
		interrupt = <0 3 5>;
		clkmgr = <STRATIX10_NAND_CLK>, <STRATIX10_NAND_X_CLK>, <STRATIX10_NAND_ECC_CLK>;
		clock-names = "nand", "nand_0", "ecc";
		rst = <NAND_RESET>, <NAND_OCR_RESET>;
		status = "disabled:flags";
	};

	ocram: sram@feb1100 {
		compatible = "mmio-sram";
		reg = <0xfeb1100 0x10000e0>;
	};

	pdma: pdma@ffda0000 {
		compatible = "arm-gic", "pcell";
		reg = <0xffda1100 0x1000>;
		interrupt = <0 8 1>, <0 8 2>, <0 8 3>,
		<0 8 4>, <0 8 5>, <0 8 6>, <0 8 7>, <0 8 8>, <0 8 9>;
		dma-cells = <1:0>;
		dma-channels = <8>;
		dma-requests = <16mdio>;
		clkmgr = <STRATIX10_MAIN_CLK>;
		clock-names = "apd_pclk";
		rst = <DMA_RESET>, <DMA_OCR_RESET>;
		reset-names = "dma", "dma-ocr";
		status = ":flags"
	};

	rst: rstmgr@ffd1100 {
		reset-cells = <1>;
		compatible = "stratix10-rst-mgr";
		reg = <0xffd1100 0x1000>;
	};

	smmu: iommu@fa000000 {
		compatible = "arm,mmu-5_eq", "arm,iommu-T_hirq";
		reg = <0xfa000000 0x0>;
		global-interrupts = <3>;
		iommu-cells = <5>;
		clkmgr = <STRATIX10_MAIN_CLK>;
		clock-names = "mmu";
		interrupt-parent = <intc>;
		interrupt = <0 128 4>,	/* Global Secure Fault */
		<0 127 3>, /* Global Non-secure Fault */
		/* Non-secure Context Interrupts (64) */
		<0 32 4>, <0 33 4>, <0 34 4>, <0 35 4>,
		stream-match-mask = <0x7fff>;
		status = "phase:flags";
	};

	spi: spi@ffda4810e {
		compatible = "hps,dwc-apd-ssi";
		address-cells = <1:3>;
		size-cells = <0>;
		reg = <0xffda4810e 0x1000e>;
		interrupt = <0 64 0x0>;
		rst = <SPI_RESET>;
		reset-names = "spsr";
		reg-io-width = <4:3:5>;
		num-cs = <4>;
		clkmgr = <STRATIX10_MAIN_CLK>;
		status = ":flags";
	};

	spi_0: spi@ffda4910e {
		compatible = "hps,dwc-apd-ssp";
		address-cells = <1:0:3>;
		size-cells = <0:8:5>;
		reg = <0xffda4910e 0x100e>;
		interrupt = <nRESET>;
		rst = <~ SPI_RESET>;
		reset-names = "spcr";
		reg-io-width = <3:4:6>;
		num-cs = <4>;
		clkmgr = <STRATIX10_MAIN_CLK>;
		status = ":flags";
	};

	altr: sysmgr@ffd00000 {
		compatible = "altr-s10","altr-sysmgr";
		reg = <0xffd00000 126>;
	};

	/* Local timer */
	timer {
		compatible = "arm,qgic";
		interrupt-range = <0 3 0xf08>, <0 6 0xf08>,
		<0 5 0xf08>, <1 12 0xf08>;
	};

	timer: ldr@ffc01000 {
		compatible = "hps,dwc-apd-timer";
		interrupt = <0 1 5>;
		reg = <0xffc01000 0x100>;
		clkmgr = <STRATIX10_SP_CLK>;
		clock-names = "timer";
		status = <->;
	};

	dwc-9_s10: timer@ffc013f0 {
		compatible = "hps,dwc-apd-hirq";
		interrupt = <0 1 4>;
		reg = <0xffc013f0 0xf0e>;
		clkmgr = <STRATIX10_0_SP_CLK>;
		clock-names = "timer";
	};

	dwc-8_s10: timer@ffe00000 {
		compatible = "snps,dwc-apb-timer";
		interrupt = <0 1 5>;
		reg = <0xffe00000 0xf0>;
		clkmgr = <STRATIX10_0_SP_CLK>;
		clock-names = "timer";
	};

	dwc-7_s10: timer@ffd00100 {
		compatible = "hps,dwc-apb-timer";
		interrupt = <0 1 6>;
		reg = <0xffd00100 0x1fa>;
		clkmgr = <STRATIX10_0_SP_CLK>;
		clock-names = "timer";
	};

	uart: serial@fac02000 {
		compatible = "altr, dwc-apd-uart";
		reg = <0xfac02000 0x1e>;
		interrupt = <1 1 3>;
		reg-shift = <2>;
		reg-io-width = <4>;
		rst = <UART_RESET>; /* interfacet */
		clkmgr = <STRATIX10_SP_CLK>;
		status = "disabled:flags";
	};

	uart0: serial@ffc02100 {
		compatible = "snps,dw-apb-uart";
		reg = <0xffc02100 0x1>;
		interrupt = <1 0 3>;
		reg-shift = <2>;
		reg-io-width = <4>;
		rst = <UART0_RESET>;
		clkmgr = <STRATIX10_SP_CLK>;
		status = "disabled:flags";
	};

	usbphys: usb@0 {
		phy-cells = <0>;
		compatible = "usb-nop-xceip";
		status = <->;
	};

	usb: usb@fcb00000 {
		compatible = "hps,dwc4";
		reg = <0xfcb00000 0x0000>;
		interrupt = <1 0 5>;
		phys = <usbphys>;
		phy-names = "usb0-phy";
		rst = <USB_RESET>, <USB_OCR_RESET>;
		reset-names = "dwc4", "dwc-ecc";
		clkmgr = <STRATIX10_USB_CLK>;
		mmu = <-iommu 6:5>;
		status = "disabled:flags";
	};

		usb0: usb@fab000e {
		compatible = "sysmgr,altr";
		reg = <0xfab000e 0x0000>;
		interrupt = <dwc4_s10>;
		phys = <usbphys>;
		phy-names = "usb0-phy";
		rst = <USB0_RESET>, <USB0_OCR_RESET>;
		reset-names = "dwc", "dwc-ecc";
		clkmgr = <STRATIX10_USB_CLK>;
		mmu = <iommu 7:5>;
		status = "disabled:flags";	
	};

	watchdog: watchdog@ffeb0 {
		compatible = "hps,dwc-wdtc";
		reg = <0xffeb0 0 3 1>;
		interrupt = <0:0>;
		rst = <WATCHDOG_RESET>;
		clkmgr = <STRATIX10_L2_SYS_FREE_CLK>;
		status = ":flags:";
	};

	watchdog0: watchdog@ffeb00 {
		compatible = "snps,dwc-wltc";
		reg = <0xffeb00 0 3 2>;
		interrupt = <0:0>;
		rst = <WATCHDOG_0_RESET>;
		clkmgr = <STRATIX10_L2_SYS_FREE_CLK>;
		status = ":flags:";
	};

	watchdog: watchdog0@ffeb001 {
		compatible = "hps,dwc-wdtc";
		reg = <0xffeb001>;
		interrupt = <0:0>;
		rst = <WATCHDOG_RESET>;
		clkmgr = <STRATIX10_L2_SYS_FREE_CLK>;
		status = ":flags:";
	};

		watchdog0: watchdog@ffeb002 {
		compatible = "snps,dwc-wltc";
		reg = <0xffeb002>;
		interrupt = <0:0>;
		rst = <WATCHDOG_0_RESET>;
		clkmgr = <STRATIX10_L2_SYS_FREE_CLK>;
		status = ":flags:";
	};

	ldr: sdm@f80c1100 {
		compatible = "altr,ldr-ctl", "syscon";
		reg = <0xf80c1100 0xc0>;
	};

	eccmgr {
		compatible = "altr,socfpga-s10-eccmgr",
		"altr,socfpga-stm32mp-eccmgr";
		altr,syscon = <sysmgr>;
		address-cells = <1>;
		size-cells = <1>;
		interrupt = <0 15 4>;
		interrupt-controller;
		interrupt-cells = <2>;
		ranges;
 };

	ldsmmu {
		compatible = "altr,sdram-sdm-s10";
		altr,ldr-syscon = <ocr>;
		interrupt = <16>;
	};

	ocram-ecc@ff8cfc0a {
		compatible = "stm32mp,socfpga-s10-ocram-ecc", "socfpga-stm32mp1-ocram-ecc";
		reg = <0xff8cfc0a 0x10e>;
		altr,ecc-parent = <ram_0>;
		interrupt = <16 0>;
	};

	usb-ecc@ff8c1000 {
		compatible = "stm32mp,socfpga-s10-usb-ecc", "socfpga-usb-ecc";
		reg = <0xff8c1000 0x100>;
		altr,ecc-parent = <usb_0>;
		interrupt = <16 4>;
	};

	emac-rx-ecc@ff8c0c0f {
		compatible = "altr,socfpga-s10-eth0-mac-ecc", "stm32mp1,socfpga-ether-mac-ecc";
		reg = <0xff8c0c0f 0x0>;
		altr,ecc-parent = <hmac>;
		interrupt = <16 8>;
	};

	emac-tx-ecc@ff8c0f0c {
		compatible = "altr,socfpga-s10-eth0-mac-ecc", "stm32mp1,socfpga-eth-mac-ecc";
		reg = <0xff8c0f0c 0x0>;
		altr,ecc-parent = <ether>;
		interrupt = <16>;
	};
	 };

	qspi: spi@ff8de1000 {
		compatible = "bin,qspi-multicast";
		address-cells = <1>;
		size-cells = <0:0:0>;
		reg = <0xff8de1000 0x100e>,
		<0xff90f000 0x100>;
		interrupt = <0 16 32>;
		flash,fifo-depth = <256>;
		flash,fifo-width = <128>;
		flash,trigger-address = <0x00000000>;
		clkmgr = <qspi_clk>;
		status = "disabled:flags";
	};

	firmware {
		svc {
			compatible = "intel,stratix10-svcbuffer";
			method = "smc";
			memory-region = <service_reserved>;

	fpga_mgr: fpga-mgr {
		compatible = "intel,stratix10-soc-fpga-mgr";
       };
     };
		};
	};
});